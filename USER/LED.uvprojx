# Keil uVision project LED.uvprojx, settings and files
target LED (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\FWLIB\inc;..\HARDWARE\LCD12864;..\HARDWARE\FPGASPI;..\HARDWARE\DAC;..\HARDWARE\DAC8560;..\HARDWARE\Relay;..\HARDWARE\Timer;..\HARDWARE\Flash;..\HARDWARE\TFTLCD;..\HARDWARE\KeyBoard;..\HARDWARE\ADS1118;..\HARDWARE\AD9854;..\TASK\GUITask.h
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LCD12864/: LCD12864.c
    ../HARDWARE/FPGASPI/: FPGASPI.c
    ../HARDWARE/DAC/: dac.c
    ../HARDWARE/Relay/: Relay.c
    ../HARDWARE/DAC8560/: DAC8560_Driver.c
    ../HARDWARE/PID/: pid.c
    ./: filter.c PulseMeter.c
    ../HARDWARE/Flash/: stmflash.c
    ../HARDWARE/KeyBoard/: KeyBoard.c
    ../HARDWARE/ADS1118/: ADS1118_SPI.c
    ../HARDWARE/AD9854/: AD9854.c
    ../HARDWARE/TFTLCD/: lcd.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/sys/: sys.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c stm32f4xx_dac.c stm32f4xx_tim.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_exti.c
  group TASK
    ../Task/: GUITask.c
  group README
    ../: readme.txt
